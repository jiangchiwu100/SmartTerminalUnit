# IAR project FATFS.ewp, settings and files
configuration FTUBoot (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_FULL_LL_DRIVER; __CNUC__
  ICCARM.CCIncludePath2: ../CORE; ../USER; ../HALLIB/STM32F4xx_HAL_Driver/Inc; ../SYSTEM/sys; ../HARDWARE/LED; ../HARDWARE/SDRAM; ../HARDWARE/SPI; ../HARDWARE/W25QXX; ../FATFS/exfuns; ../FATFS/src; ../HARDWARE/FM25Vxx; ../HARDWARE/SDRAM; ../HARDWARE/IWDG; ../HARDWARE/IAP; ../Module/tftp; ../Module/W5500/Inc; ../Module/Database; ../../RTT_P2P/Project/Protocol/nanopb; ../../RTT_P2P/Project/DistributionComponents
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../SYSTEM/sys/: systemconfig.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_dma.c stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_ll_utils.c stm32f4xx_ll_rcc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/IAP/: uartDriver.c IapControl.c MainFlashOperate.c MainBoardBoot.c
    ../HARDWARE/FM25Vxx/: fm25v10.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
  group README
    ../: readme.txt
  group Module/W5500
    ../Module/W5500/Src/: device.c socket.c ult.c w5500.c
  group TFTP
    ../Module/tftp/: tftp.c tftp_demo.c
  group Database
    ../../RTT_P2P/Project/Protocol/nanopb/: pb_common.c pb_decode.c pb_encode.c
    ../Module/database/: database.c
    ../../RTT_P2P/Project/DistributionComponents/: station.pb.c
