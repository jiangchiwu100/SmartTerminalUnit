# Keil uVision project STU.uvprojx, settings and files
target FTU_V03.020 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin !L --output ftu_v03.021.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER, USE_FULL_LL_DRIVER,RT_USING_ARM_LIBC, ARM_MATH_CM4, __CC_ARM,__TARGET_FPU_VFP
  c include: applications;.;Libraries\STM32F4xx_HAL_Driver\Inc;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;.\drivers;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\net;..\..\components\dfs\filesystems\net\socket;..\..\components\dfs\filesystems\romfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;..\..\components\drivers\spi\misc;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include\netif;..\..\config;..\..\components\dfs\filesystems\uffs;..\..\components\dfs\filesystems\uffs\src;..\..\components\dfs\filesystems\uffs\src\inc;.\Libraries\STM32F4xx_HAL_Driver\Src;.\applications\common_data;.\applications\ptotocol\iec60870;..\..\components\single_list;.\applications\protect;.\applications\calculator;.\applications\tcp_server;.\applications\queue;.\applications\file_operate;.\applications\wave_recording;..\..\components\mini_xml;..\..\components\malloc;.\applications\point_table_config;.\applications\lkdGui\gui;.\applications\lkdGui\protocol;.\applications\lkdGui\protocol;.\applications\struct2json\struct2json\inc;.\applications\struct2json\user;.\applications\ptotocol\iec61850;.\applications\md5
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: startup.c application.c
    ./applications/MultiThread/: multi_thread.c
    ./applications/common_data/: common_data.c
    ./applications/point_table_config/: point_table_config.c
    ./applications/protect/: breaker_protect.c load_switch_ctrl.c distributed_protect.c other_protect.c
    ./applications/calculator/: calculator.c
    ./applications/tcp_server/: tcp_server.c
    ./applications/queue/: queue.c
    ./applications/file_operate/: file_operate.c
    ./applications/wave_recording/: wave_recording.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c drv_sdram.c drv_mpu.c drv_nand.c drv_eth.c drv_iic.c drv_spi.c drv_spi_flash.c
    ./drivers/: drv_gpio.c drv_usart.c drv_io_spi.c drv_fm25vxx.c drv_w5500_conf.c drv_w5500_socket.c drv_timer.c drv_di.c drv_do.c drv_rtc.c drv_led.c drv_ad7616.c drv_wdg.c drv_pcf8563.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_usart.c
    ../../../RTT_P2P/Project/HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_utils.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/net/: dfs_net.c net_netdb.c net_sockets.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    ../../components/dfs/filesystems/uffs/: dfs_uffs.c uffs_nandif.c uffs_rtthread.c
    ../../components/dfs/filesystems/uffs/src/uffs/: uffs_badblock.c uffs_blockinfo.c uffs_buf.c uffs_crc.c uffs_debug.c uffs_device.c uffs_ecc.c uffs_fd.c uffs_find.c uffs_flash.c uffs_fs.c uffs_init.c uffs_mem.c uffs_mtb.c uffs_pool.c uffs_public.c uffs_tree.c uffs_utils.c uffs_version.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group lwIP
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group lkdGui
    ./applications/lkdGui/protocol/: hmi_101_app.c hmi_101_disk.c
    ./applications/lkdGui/gui/: gui_101_cmd.c gui_common.c lkdGuiMenu.c lkdGuiWindow.c GUIdisplaydef.h GUIdisplay.c GUIdisplay.h userVariable.c hmiInOut.c
  group IEC60870
    ./applications/ptotocol/iec60870/: dlt634_5101slave_disk.c dlt634_5101slave_app.c dlt634_5104slave_disk.c dlt634_5104slave_app.c channel_monitor.c
  group IEC61850
    ./applications/ptotocol/iec61850/: goose.c
  group single_list
    ../../components/single_list/: single_list.c
  group DSP_LIB
    ./Libraries/DSPLIB/: arm_cortexM4lf_math.lib
  group min_xml
    ../../components/mini_xml/: mini_xml.c
  group malloc
    ../../components/malloc/: malloc.c
  group struct2json
    ./applications/struct2json/struct2json/src/: s2j.c cJSON.c
    ./applications/struct2json/user/: Interface_S2J.c JsonFileOperation.c
  group README
    ./: read_me.txt
  group Distribution
    ../../../RTT_P2P/Project/Distribution/Src/: distribution_connect.c distribution_helper.c distribution_interface.c distribution_test_case.c distribution_transfer.c distribution_online.c distribution_monitor.c fault_deal.c fault_insulate.c fault_removal.c fault_treatment.c parse_implement.c power_area.c topology.c
  group Distribution/Mutal
    ../../../RTT_P2P/Project/Distribution/Src/: RouterDatagram.c Router.c extern_mutual.c
  group Distribution/Components
    ../../../RTT_P2P/Project/Components/Src/: Buffer.c helper.c list.c RingQueue.c
    ../../../RTT_P2P/Project/DistributionComponents/: log.c log.pb.c station.pb.c station.c
  group Distribution/Simulatin
    ../../../RTT_P2P/Project/Distribution/Src/: station_manager.c logical_simulation.c
  group Protocol/nanopb
    ../../../RTT_P2P/Project/Protocol/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Protocol/RTUself
    ../../../RTT_P2P/Project/Protocol/Src/: CRC16.c Datagram.c RtuFrame.c
  group Distribution/Board
    ../../../RTT_P2P/Project/Board/Src/: SerialPort.c w5500_server.c database.c drv_w5500.c miscellaneous.c ethernet_hook.c
  group Distribution/APP
    ../../../RTT_P2P/Project/APP/Src/: communicaton.c distribution_app.c logical_app.c logical_simulation_app.c mutal_app.c
    H:/CodeResourceLib/RTOS/RT-Thread/rt-thread/components/net/lwip-1.3.2/apps/: tftp.c
    ../../../RTT_P2P/Project/: readme.txt
  group libiec/goose
    ../../../LibIEC/libIEC61850/src/goose/: goose_publisher.c goose_receiver.c goose_subscriber.c
target STU_V0.01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: STU +hex
  AfterMake: fromelf --bin !L --output stu_v00.001.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: applications;.;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\STM32F4xx_HAL_Driver\Inc;Libraries\CMSIS\Include;.\drivers;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\net;..\..\components\dfs\filesystems\net\socket;..\..\components\dfs\filesystems\romfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;..\..\components\drivers\spi\misc;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include\netif;..\..\config;..\..\components\dfs\filesystems\uffs;..\..\components\dfs\filesystems\uffs\src;..\..\components\dfs\filesystems\uffs\src\inc;.\Libraries\STM32F4xx_HAL_Driver\Src;.\applications\common_data;.\applications\ptotocol\iec60870;..\..\components\single_list;.\applications\protect;.\applications\calculator;.\applications\tcp_server;.\applications\queue;.\applications\file_operate;.\applications\wave_recording;..\..\components\mini_xml;..\..\components\malloc;.\applications\point_table_config;.\applications\lkdGui\gui;.\applications\lkdGui\protocol;.\applications\lkdGui\protocol;.\applications\struct2json\struct2json\inc;.\applications\struct2json\user;.\applications\ptotocol\iec61850;.\applications\md5;..\..\..\RTT_P2P\Project\Components\Inc;..\..\..\RTT_P2P\Project\Protocol\Inc;..\..\..\RTT_P2P\Project\Distribution\Inc;..\..\..\RTT_P2P\Project\DistributionComponents;..\..\..\RTT_P2P\Project\Protocol\nanopb;..\..\..\RTT_P2P\Project\Protocol\APP\Inc;..\..\..\RTT_P2P\Project\APP\Inc;..\..\..\RTT_P2P\Project\Board\Inc;..\..\..\RTT_P2P\Project\APP\Inc;..\..\..\LibIEC\libIEC61850\src\goose
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: as above
