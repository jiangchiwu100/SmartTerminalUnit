# IAR project STU.ewp, settings and files
configuration FTU_V03.020 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; RT_USING_ARM_LIBC; ARM_MATH_CM4; __CC_ARM; __TARGET_FPU_VFP
  ICCARM.CCIncludePath2: applications; .; Libraries/STM32F4xx_HAL_Driver/Inc; Libraries/CMSIS/Device/ST/STM32F4xx/Include; Libraries/CMSIS/Include; ./drivers; ../../include; ../../libcpu/arm/cortex-m4; ../../libcpu/arm/common; ../../components/dfs/include; ../../components/dfs/filesystems/devfs; ../../components/dfs/filesystems/elmfat; ../../components/dfs/filesystems/net; ../../components/dfs/filesystems/net/socket; ../../components/dfs/filesystems/romfs; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/spi; ../../components/drivers/include; ../../components/drivers/spi/sfud/inc; ../../components/drivers/include; ../../components/drivers/spi/misc; ../../components/finsh; ../../components/libc/compilers/armlibc; ../../components/net/lwip-1.4.1/src; ../../components/net/lwip-1.4.1/src/include; ../../components/net/lwip-1.4.1/src/include/ipv4; ../../components/net/lwip-1.4.1/src/arch/include; ../../components/net/lwip-1.4.1/src/include/netif; ../../config; ../../components/dfs/filesystems/uffs; ../../components/dfs/filesystems/uffs/src; ../../components/dfs/filesystems/uffs/src/inc; ./Libraries/STM32F4xx_HAL_Driver/Src; ./applications/common_data; ./applications/ptotocol/iec60870; ../../components/single_list; ./applications/protect; ./applications/calculator; ./applications/tcp_server; ./applications/queue; ./applications/file_operate; ./applications/wave_recording; ../../components/mini_xml; ../../components/malloc; ./applications/point_table_config; ./applications/lkdGui/gui; ./applications/lkdGui/protocol; ./applications/lkdGui/protocol; ./applications/struct2json/struct2json/inc; ./applications/struct2json/user; ./applications/ptotocol/iec61850; ./applications/md5; ../../../LibIEC/libIEC61850/src/common/inc; ../../../LibIEC/libIEC61850/src/mms/inc; ../../../LibIEC/libIEC61850/src/mms/inc_private; ../../../LibIEC/libIEC61850/src/hal/inc; ../../../LibIEC/libIEC61850/src/mms/iso_mms/asn1c; ../../../LibIEC/libIEC61850/src/tls; ../../../LibIEC/libIEC61850/src/logging; ../../../LibIEC/libIEC61850/src/iec61850/inc; ../../../LibIEC/libIEC61850/src/iec61850/inc_private; ../../../LibIEC/libIEC61850/src/goose; ../../../LibIEC/libIEC61850/third_party/winpcap/Include; ../../../LibIEC/libIEC61850/config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
configuration STU_V0.01 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; ARM_MATH_CM4; __TARGET_FPU_VFP; _TIMESPEC_DEFINED; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: applications; .; Libraries/CMSIS/Device/ST/STM32F4xx/Include; Libraries/STM32F4xx_HAL_Driver/Inc; Libraries/CMSIS/Include; ./drivers; ../../include; ../../libcpu/arm/cortex-m4; ../../libcpu/arm/common; ../../components/dfs/include; ../../components/dfs/filesystems/devfs; ../../components/dfs/filesystems/elmfat; ../../components/dfs/filesystems/net; ../../components/dfs/filesystems/net/socket; ../../components/dfs/filesystems/romfs; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/include; ../../components/drivers/spi; ../../components/drivers/include; ../../components/drivers/spi/sfud/inc; ../../components/drivers/include; ../../components/drivers/spi/misc; ../../components/finsh; E:\Users\ZYF\Documents\IAR Embedded Workbench\arm\SmartTerminalUnit\FTU\components\libc\compilers\dlib; ../../components/net/lwip-1.4.1/src; ../../components/net/lwip-1.4.1/src/include; ../../components/net/lwip-1.4.1/src/include/ipv4; ../../components/net/lwip-1.4.1/src/arch/include; ../../components/net/lwip-1.4.1/src/include/netif; ../../config; ../../components/dfs/filesystems/uffs; ../../components/dfs/filesystems/uffs/src; ../../components/dfs/filesystems/uffs/src/inc; ./Libraries/STM32F4xx_HAL_Driver/Src; ./applications/common_data; ./applications/ptotocol/iec60870; ../../components/single_list; ./applications/protect; ./applications/calculator; ./applications/tcp_server; ./applications/queue; ./applications/file_operate; ./applications/wave_recording; ../../components/mini_xml; ../../components/malloc; ./applications/point_table_config; ./applications/lkdGui/gui; ./applications/lkdGui/protocol; ./applications/lkdGui/protocol; ./applications/struct2json/struct2json/inc; ./applications/struct2json/user; ./applications/ptotocol/iec61850; ./applications/md5; ../../../RTT_P2P/Project/Components/Inc; ../../../RTT_P2P/Project/Protocol/Inc; ../../../RTT_P2P/Project/Distribution/Inc; ../../../RTT_P2P/Project/DistributionComponents; ../../../RTT_P2P/Project/Protocol/nanopb; ../../../RTT_P2P/Project/Protocol/APP/Inc; ../../../RTT_P2P/Project/APP/Inc; ../../../RTT_P2P/Project/Board/Inc; ../../../RTT_P2P/Project/APP/Inc; ../../../LibIEC/libIEC61850/src/mms/iso_mms/asn1c; ../../../LibIEC/libIEC61850/src/common/inc; ../../../LibIEC/libIEC61850/src/mms/inc; ../../../LibIEC/libIEC61850/src/mms/inc_private; ../../../LibIEC/libIEC61850/src/tls; ../../../LibIEC/libIEC61850/src/logging; ../../../LibIEC/libIEC61850/src/iec61850/inc; ../../../LibIEC/libIEC61850/src/iec61850/inc_private; ../../../LibIEC/libIEC61850/src/goose; ../../../LibIEC/libIEC61850/third_party/winpcap/Include; ../../../LibIEC/libIEC61850/src/hal/inc; ../../../LibIEC/libIEC61850/config; ../../../RTT_P2P/Project/libiec_hal/inc; ../../../LibIEC/libIEC61850/GooseTransmission
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: STU.hex
  ILINK.IlinkOutputFile: STU.out
  ILINK.IlinkIcfFile: stm32f429_flash.icf
  ILINK.IlinkAdditionalLibs: E:\Users\ZYF\Documents\IAR Embedded Workbench\arm\SmartTerminalUnit\FTU\bsp\stm32f429-apollo\Libraries\DSPLIB\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: application.c startup.c
    applications/protect/: breaker_protect.c distributed_protect.c load_switch_ctrl.c other_protect.c
    applications/calculator/: calculator.c
    applications/common_data/: common_data.c
    applications/file_operate/: file_operate.c
    applications/MultiThread/: multi_thread.c
    applications/point_table_config/: point_table_config.c
    applications/queue/: queue.c
    applications/tcp_server/: tcp_server.c
    applications/wave_recording/: wave_recording.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Distribution
    ../../../RTT_P2P/Project/Distribution/Src/: distribution_connect.c distribution_helper.c distribution_interface.c distribution_monitor.c distribution_online.c distribution_test_case.c distribution_transfer.c fault_deal.c fault_insulate.c fault_removal.c fault_treatment.c parse_implement.c power_area.c topology.c
  group Distribution/APP
    ../../../RTT_P2P/Project/APP/Src/: communicaton.c distribution_app.c logical_app.c logical_simulation_app.c mutal_app.c
    ../../../RTT_P2P/Project/: readme.txt
    H:/CodeResourceLib/RTOS/RT-Thread/rt-thread/components/net/lwip-1.3.2/apps/: tftp.c
  group Distribution/Board
    ../../../RTT_P2P/Project/Board/Src/: database.c drv_w5500.c ethernet_hook.c miscellaneous.c SerialPort.c w5500_server.c
  group Distribution/Components
    ../../../RTT_P2P/Project/Components/Src/: Buffer.c helper.c list.c RingQueue.c
    ../../../RTT_P2P/Project/DistributionComponents/: log.c log.pb.c station.c station.pb.c
  group Distribution/Mutal
    ../../../RTT_P2P/Project/Distribution/Src/: extern_mutual.c Router.c RouterDatagram.c
  group Distribution/Simulatin
    ../../../RTT_P2P/Project/Distribution/Src/: logical_simulation.c station_manager.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c libc.h rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.h unistd.h
  group Drivers
    drivers/: board.c drv_ad7616.c drv_di.c drv_do.c drv_eth.c drv_fm25vxx.c drv_gpio.c drv_iic.c drv_io_spi.c drv_led.c drv_mpu.c drv_nand.c drv_pcf8563.c drv_rtc.c drv_sdram.c drv_spi.c drv_spi_flash.c drv_timer.c drv_usart.c drv_w5500_conf.c drv_w5500_socket.c drv_wdg.c stm32f4xx_it.c
  group DSP_LIB
    Libraries/DSPLIB/: arm_cortexM4lf_math.lib
  group Filesystem
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/net/: dfs_net.c net_netdb.c net_sockets.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group IEC60870
    applications/ptotocol/iec60870/: channel_monitor.c dlt634_5101slave_app.c dlt634_5101slave_disk.c dlt634_5104slave_app.c dlt634_5104slave_disk.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libiec/common
    ../../../LibIEC/libIEC61850/src/common/: array_list.c buffer_chain.c byte_buffer.c conversions.c errno.c lib_memory.c linked_list.c map.c mem_alloc_linked_list.c simple_allocator.c string_map.c string_utilities.c
  group libiec/goose
    ../../../LibIEC/libIEC61850/src/goose/: goose_publisher.c goose_receiver.c goose_subscriber.c
  group libiec/GooseAPP
    ../../../LibIEC/libIEC61850/GooseTransmission/: goose_publisher_beat.c
    ../../../LibIEC/libIEC61850/App/: goose_publisher_example.c goose_subscriber_example.c
  group libiec/hal
    ../../../RTT_P2P/Project/libiec_hal/ethernet/dtu_rtt/: ethernet_rtt.c
    ../../../RTT_P2P/Project/libiec_hal/filesystem/dtu_rtt/: file_provider_rtt.c
    ../../../RTT_P2P/Project/libiec_hal/socket/dtu_rtt/: socket_rtt.c
    ../../../RTT_P2P/Project/libiec_hal/thread/rt_thread/: thread_rtt.c
    ../../../LibIEC/Project/libiec_hal/time/dtu_core/: time_libiec.c
  group libiec/iec61850
    ../../../LibIEC/libIEC61850/src/iec61850/server/impl/: client_connection.c ied_server.c ied_server_config.c
    ../../../LibIEC/libIEC61850/src/iec61850/client/: client_control.c client_goose_control.c client_report.c client_report_control.c client_sv_control.c ied_connection.c
    ../../../LibIEC/libIEC61850/src/iec61850/server/mms_mapping/: control.c logging.c mms_goose.c mms_mapping.c mms_sv.c reporting.c
    ../../../LibIEC/libIEC61850/src/iec61850/common/: iec61850_common.c
  group libiec/iec61850/model
    ../../../LibIEC/libIEC61850/src/iec61850/server/model/: cdc.c config_file_parser.c dynamic_model.c model.c
  group libiec/logging
    ../../../LibIEC/libIEC61850/src/logging/drivers/: log_storage.c
  group libiec/mms
    ../../../LibIEC/libIEC61850/src/mms/iso_mms/asn1c/: AccessResult.c Address.c AlternateAccess.c AlternateAccessSelection.c asn_codecs_prim.c asn_SEQUENCE_OF.c asn_SET_OF.c ber_decoder.c ber_tlv_length.c ber_tlv_tag.c BIT_STRING.c BOOLEAN.c ConcludeRequestPDU.c ConcludeResponsePDU.c ConfirmedErrorPDU.c ConfirmedRequestPdu.c ConfirmedResponsePdu.c ConfirmedServiceRequest.c ConfirmedServiceResponse.c constr_CHOICE.c constr_SEQUENCE.c constr_SEQUENCE_OF.c constr_SET_OF.c constr_TYPE.c constraints.c Data.c DataAccessError.c DataSequence.c DefineNamedVariableListRequest.c DefineNamedVariableListResponse.c DeleteNamedVariableListRequest.c DeleteNamedVariableListResponse.c der_encoder.c FloatingPoint.c GeneralizedTime.c GetNamedVariableListAttributesRequest.c GetNamedVariableListAttributesResponse.c GetNameListRequest.c GetNameListResponse.c GetVariableAccessAttributesRequest.c GetVariableAccessAttributesResponse.c Identifier.c IndexRangeSeq.c InformationReport.c InitiateErrorPdu.c InitiateRequestPdu.c InitiateResponsePdu.c InitRequestDetail.c InitResponseDetail.c INTEGER.c Integer16.c Integer32.c Integer8.c ListOfVariableSeq.c MmsPdu.c MMSString.c NativeEnumerated.c NativeInteger.c NULL.c ObjectClass.c ObjectName.c OCTET_STRING.c ParameterSupportOptions.c per_decoder.c per_encoder.c per_support.c ReadRequest.c ReadResponse.c RejectPDU.c ScatteredAccessDescription.c ServiceError.c ServiceSupportOptions.c StructComponent.c TimeOfDay.c TypeSpecification.c UnconfirmedPDU.c UnconfirmedService.c Unsigned16.c Unsigned32.c Unsigned8.c UtcTime.c UTF8String.c VariableAccessSpecification.c VariableSpecification.c VisibleString.c WriteRequest.c WriteResponse.c xer_decoder.c xer_encoder.c xer_support.c
    ../../../LibIEC/libIEC61850/src/mms/iso_acse/: acse.c
    ../../../LibIEC/libIEC61850/src/mms/asn1/: asn1_ber_primitive_value.c ber_decode.c ber_encoder.c ber_integer.c
    ../../../LibIEC/libIEC61850/src/mms/iso_cotp/: cotp.c
    ../../../LibIEC/libIEC61850/src/mms/iso_client/: iso_client_connection.c
    ../../../LibIEC/libIEC61850/src/mms/iso_server/: iso_connection.c iso_server.c
    ../../../LibIEC/libIEC61850/src/mms/iso_common/: iso_connection_parameters.c
    ../../../LibIEC/libIEC61850/src/mms/iso_presentation/: iso_presentation.c
    ../../../LibIEC/libIEC61850/src/mms/iso_session/: iso_session.c
    ../../../LibIEC/libIEC61850/src/mms/iso_mms/server/: mms_access_result.c mms_association_service.c mms_device.c mms_domain.c mms_file_service.c mms_get_namelist_service.c mms_get_var_access_service.c mms_identify_service.c mms_information_report.c mms_journal.c mms_journal_service.c mms_named_variable_list.c mms_named_variable_list_service.c mms_read_service.c mms_server.c mms_server_common.c mms_server_connection.c mms_status_service.c mms_value_cache.c mms_write_service.c
    ../../../LibIEC/libIEC61850/src/mms/iso_mms/client/: mms_client_common.c mms_client_connection.c mms_client_files.c mms_client_get_namelist.c mms_client_get_var_access.c mms_client_identify.c mms_client_initiate.c mms_client_journals.c mms_client_named_variable_list.c mms_client_read.c mms_client_status.c mms_client_write.c
    ../../../LibIEC/libIEC61850/src/mms/iso_mms/common/: mms_common_msg.c mms_type_spec.c mms_value.c
  group libiec/sampled_values
    ../../../LibIEC/libIEC61850/src/sampled_values/: sv_publisher.c sv_subscriber.c
  group libiec/ServerAPP
    ../../../LibIEC/libIEC61850/App/: iec61850_app.c ied_data_ref.c ied_data_ref.h ied_data_ref_init.c server_datamapping.c server_example_goose.c static_model.c
  group lkdGui
    applications/lkdGui/gui/: gui_101_cmd.c gui_common.c GUIdisplay.c GUIdisplay.h GUIdisplaydef.h hmiInOut.c lkdGuiMenu.c lkdGuiWindow.c userVariable.c
    applications/lkdGui/protocol/: hmi_101_app.c hmi_101_disk.c
  group lwIP
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem_lwip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ./: lwipconfig.h
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group min_xml
    ../../components/mini_xml/: mini_xml.c
  group Protocol/nanopb
    ../../../RTT_P2P/Project/Protocol/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Protocol/RTUself
    ../../../RTT_P2P/Project/Protocol/Src/: CRC16.c Datagram.c RtuFrame.c
  group README
    ./: read_me.txt
  group single_list
    ../../components/single_list/: single_list.c
  group STM32_HAL
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c
    ../../../RTT_P2P/Project/HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_utils.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group struct2json
    applications/struct2json/struct2json/src/: cJSON.c s2j.c
    applications/struct2json/user/: Interface_S2J.c JsonFileOperation.c
