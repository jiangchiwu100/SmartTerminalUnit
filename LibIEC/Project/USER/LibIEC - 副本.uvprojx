# Keil uVision project LibIEC - 副本.uvprojx, settings and files
target RTT_P2P (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429xx,USE_FULL_LL_DRIVER,HSE_VALUE=25000000U,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Board\Inc;..\W5500\Inc;..\APP\Inc;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\..\..\GooseTest\src\common\inc;..\..\..\GooseTest\src\mms\inc;..\..\..\GooseTest\src\mms\inc_private;..\..\..\GooseTest\src/hal/inc;..\..\..\GooseTest\src/mms/iso_mms/asn1c;..\..\..\GooseTest\src/tls;..\..\..\GooseTest\src\logging;..\..\..\GooseTest\src\iec61850/inc;..\..\..\GooseTest\src/iec61850/inc_private;..\..\..\GooseTest\src/goose;..\..\..\GooseTest\third_party/winpcap/Include;..\..\..\GooseTest\config;..\libiec_hal\inc;..\Components\Inc;..\LWIP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../APP/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c w5500_demo.c BasicModule.c
    ./RTE/RTOS/: startup.c
  group Module/W5500
    ../W5500/Src/: device.c socket.c ult.c w5500.c
  group Drivers/CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group Drivers/HAL_LIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_eth.c
  group Drivers/LL_LIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_exti.c stm32f4xx_ll_utils.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_usart.c stm32f4xx_ll_tim.c stm32f4xx_ll_dma.c
  group Drivers/Board
    ../Board/Src/: led.c spi.c DeviceIO.c drv_sdram.c SerialPort.c DP83848.c
    ../LWIP/: lwip_comm.c ethernetif.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group Components
    ../Components/Src/: Buffer.c
  group libiec/common
    ../../../GooseTest/src/common/: array_list.c buffer_chain.c byte_buffer.c conversions.c lib_memory.c linked_list.c map.c mem_alloc_linked_list.c simple_allocator.c string_map.c string_utilities.c errno.c
  group libiec/goose
    ../../../GooseTest/src/goose/: goose_publisher.c goose_receiver.c goose_subscriber.c
  group libiec/iec61850
    ../../../GooseTest/src/iec61850/client/: client_control.c client_goose_control.c client_report.c client_report_control.c client_sv_control.c ied_connection.c
    ../../../GooseTest/src/iec61850/common/: iec61850_common.c
    ../../../GooseTest/src/iec61850/server/mms_mapping/: control.c logging.c mms_goose.c mms_mapping.c mms_sv.c reporting.c
    ../../../GooseTest/src/iec61850/server/impl/: client_connection.c ied_server.c ied_server_config.c
  group libiec/iec61850/model
    ../../../GooseTest/src/iec61850/server/model/: cdc.c config_file_parser.c dynamic_model.c model.c
  group libiec/logging
    ../../../GooseTest/src/logging/drivers/: log_storage.c
  group libiec/mms
    ../../../GooseTest/src/mms/asn1/: asn1_ber_primitive_value.c ber_decode.c ber_encoder.c ber_integer.c
    ../../../GooseTest/src/mms/iso_acse/: acse.c
    ../../../GooseTest/src/mms/iso_client/: iso_client_connection.c
    ../../../GooseTest/src/mms/iso_common/: iso_connection_parameters.c
    ../../../GooseTest/src/mms/iso_cotp/: cotp.c
    ../../../GooseTest/src/mms/iso_mms/asn1c/: AccessResult.c Address.c AlternateAccess.c AlternateAccessSelection.c asn_codecs_prim.c asn_SEQUENCE_OF.c asn_SET_OF.c ber_decoder.c ber_tlv_length.c ber_tlv_tag.c BIT_STRING.c BOOLEAN.c ConcludeRequestPDU.c ConcludeResponsePDU.c ConfirmedErrorPDU.c ConfirmedRequestPdu.c ConfirmedResponsePdu.c ConfirmedServiceRequest.c ConfirmedServiceResponse.c constr_CHOICE.c constr_SEQUENCE.c constr_SEQUENCE_OF.c constr_SET_OF.c constr_TYPE.c constraints.c Data.c DataAccessError.c DataSequence.c DefineNamedVariableListRequest.c DefineNamedVariableListResponse.c DeleteNamedVariableListRequest.c DeleteNamedVariableListResponse.c der_encoder.c FloatingPoint.c GeneralizedTime.c GetNamedVariableListAttributesRequest.c GetNamedVariableListAttributesResponse.c GetNameListRequest.c GetNameListResponse.c GetVariableAccessAttributesRequest.c GetVariableAccessAttributesResponse.c Identifier.c IndexRangeSeq.c InformationReport.c InitiateErrorPdu.c InitiateRequestPdu.c InitiateResponsePdu.c InitRequestDetail.c InitResponseDetail.c INTEGER.c Integer8.c Integer16.c Integer32.c ListOfVariableSeq.c MmsPdu.c MMSString.c NativeEnumerated.c NativeInteger.c NULL.c ObjectClass.c ObjectName.c OCTET_STRING.c ParameterSupportOptions.c per_decoder.c per_encoder.c per_support.c ReadRequest.c ReadResponse.c RejectPDU.c ScatteredAccessDescription.c ServiceError.c ServiceSupportOptions.c StructComponent.c TimeOfDay.c TypeSpecification.c UnconfirmedPDU.c UnconfirmedService.c Unsigned8.c Unsigned16.c Unsigned32.c UtcTime.c UTF8String.c VariableAccessSpecification.c VariableSpecification.c VisibleString.c WriteRequest.c WriteResponse.c xer_decoder.c xer_encoder.c xer_support.c
    ../../../GooseTest/src/mms/iso_mms/client/: mms_client_common.c mms_client_connection.c mms_client_files.c mms_client_get_namelist.c mms_client_get_var_access.c mms_client_identify.c mms_client_initiate.c mms_client_journals.c mms_client_named_variable_list.c mms_client_read.c mms_client_status.c mms_client_write.c
    ../../../GooseTest/src/mms/iso_mms/common/: mms_common_msg.c mms_type_spec.c mms_value.c
    ../../../GooseTest/src/mms/iso_mms/server/: mms_access_result.c mms_association_service.c mms_device.c mms_domain.c mms_file_service.c mms_get_namelist_service.c mms_get_var_access_service.c mms_identify_service.c mms_information_report.c mms_journal.c mms_journal_service.c mms_named_variable_list.c mms_named_variable_list_service.c mms_read_service.c mms_server.c mms_server_common.c mms_server_connection.c mms_status_service.c mms_value_cache.c mms_write_service.c
    ../../../GooseTest/src/mms/iso_presentation/: iso_presentation.c
    ../../../GooseTest/src/mms/iso_server/: iso_connection.c iso_server.c
    ../../../GooseTest/src/mms/iso_session/: iso_session.c
  group libiec/sampled_values
    ../../../GooseTest/src/sampled_values/: sv_publisher.c sv_subscriber.c
  group libiec/hal
    ../libiec_hal/time/dtu_core/: time.c
    ../libiec_hal/ethernet/dtu_rtt/: ethernet_rtt.c
    ../libiec_hal/thread/rt_thread/: thread_rtt.c
    ../libiec_hal/socket/dtu_rtt/: socket_rtt.c
    ../libiec_hal/filesystem/dtu_rtt/: file_provider_rtt.c
  group libiec/GooseApp
    ../APP/Src/: goose_publisher_example.c goose_subscriber_example.c
software components: RTOS:kernel 2.1.2
