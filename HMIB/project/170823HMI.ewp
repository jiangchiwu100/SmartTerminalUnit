# IAR project 170823HMI.ewp, settings and files
configuration Target 1 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ../Libraries/FWLib/inc; ../User; ../Libraries/CMSIS; ../User/include; ../User/MyGui/include; ../User/HMI101
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWLib/src/: stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c
  group USER
    ../User/: main.c systemconfig.c stm32f10x_it.c
    ../User/source/: uartDriver.c ledDriver.c switchDriver.c keyDriver.c inoutUser.c imageArray.c GuiDisplay.c ds18b20.c
  group README
    ../: readme.txt
  group Gui
    ../User/MyGui/source/: UC1698Driver.c lkdGuiBasic.c lkdGuiColour.c lkdGuiDriver.c lkdGuiFont.c lkdGuiControl.c zikuSpi.c GT21L16S2W_lib.lib
    ../User/MyGui/include/: lkdGuiUse.h
  group HMI01
    ../User/HMI101/: dlt634_HMImaster_app.c dlt634_HMImaster_disk.c
    ../User/source/: hmI101.c
