# Keil uVision project 170823HMI.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sampleHMI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\FWLib\inc;..\User;..\Libraries\CMSIS;..\User\include;..\User\MyGui\include;..\User\HMI101
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWLib/src/: stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c
  group USER
    ../User/: main.c systemconfig.c stm32f10x_it.c
    ../User/source/: uartDriver.c ledDriver.c switchDriver.c keyDriver.c inoutUser.c imageArray.c GuiDisplay.c ds18b20.c
  group README
    ../: readme.txt
  group Gui
    ../User/MyGui/source/: UC1698Driver.c lkdGuiBasic.c lkdGuiColour.c lkdGuiDriver.c lkdGuiFont.c lkdGuiControl.c zikuSpi.c GT21L16S2W_lib.lib
    ../User/MyGui/include/: lkdGuiUse.h
  group HMI01
    ../User/HMI101/: dlt634_HMImaster_app.c dlt634_HMImaster_disk.c
    ../User/source/: hmI101.c
