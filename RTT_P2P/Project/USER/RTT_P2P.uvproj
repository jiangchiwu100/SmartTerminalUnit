# Keil uVision project RTT_P2P.uvproj, settings and files
target RTT_P2P (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F429xx,USE_FULL_LL_DRIVER,HSE_VALUE=25000000U,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Board\Inc;..\W5500\Inc;..\APP\Inc;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\Components\Inc;..\Protocol\Inc;..\Distribution\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../APP/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c w5500_demo.c BasicModule.c communicaton.c
  group Distribution
    ../Distribution/Src/: topology.c power_area.c fault_treatment.c fault_removal.c distribution_interface.c distribution_test_case.c logical_simulation.c Router.c distribution_helper.c parse_implement.c station_manager.c logical_simulation_app.c
  group Module/W5500
    ../W5500/Src/: device.c socket.c ult.c w5500.c
  group Protocol/RTUself
    ../Protocol/Src/: RtuFrame.c CRC16.c
  group Components
    ../Components/Src/: Buffer.c helper.c list.c
  group Drivers/Board
    ../Board/Src/: spi.c DeviceIO.c SerialPort.c
  group Drivers/CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group Drivers/HAL_LIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c
  group Drivers/LL_LIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_exti.c stm32f4xx_ll_utils.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_spi.c stm32f4xx_ll_usart.c stm32f4xx_ll_tim.c stm32f4xx_ll_dma.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
software components: RTOS:kernel 2.1.2
