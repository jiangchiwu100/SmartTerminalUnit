# Keil uVision project project.uvprojx, settings and files
target Distribution (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread-imxrt
  AfterMake: fromelf --bin !L --output rtthread-mdk.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RT_USING_ARM_LIBC, EVK_MCIMXRM, SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6A, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186,546
  c include: applications;.;drivers;Libraries\drivers;Libraries;Libraries\utilities;Libraries\CMSIS\Include;packages\samples;packages\samples\network\tcpclient;packages\samples\network\tcpserver;packages\samples\network\udpclient;packages\samples\network\udpserver;rt-thread\include;rt-thread\libcpu\arm\cortex-m7;rt-thread\libcpu\arm\common;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\lwip-2.0.2\src\include\posix;..\LibIEC\libIEC61850\src\mms\iso_mms\asn1c;..\LibIEC\libIEC61850\src\common\inc;..\LibIEC\libIEC61850\src\mms\inc;..\LibIEC\libIEC61850\src\mms\inc_private;..\LibIEC\libIEC61850\src\tls;..\LibIEC\libIEC61850\src\logging;..\LibIEC\libIEC61850\src\iec61850\inc;..\LibIEC\libIEC61850\src\iec61850\inc_private;..\LibIEC\libIEC61850\src\goose;..\LibIEC\libIEC61850\third_party\winpcap\Include;..\LibIEC\libIEC61850\src\hal\inc;..\LibIEC\libIEC61850\config;..\RTT_P2P\Project\libiec_hal\inc;..\LibIEC\libIEC61850\GooseTransmission;..\RTT_P2P\Project\Components\Inc;..\RTT_P2P\Project\Protocol\Inc;..\RTT_P2P\Project\Distribution\Inc;..\RTT_P2P\Project\DistributionComponents;..\RTT_P2P\Project\Protocol\nanopb;..\RTT_P2P\Project\Protocol\APP\Inc;..\RTT_P2P\Project\APP\Inc;..\RTT_P2P\Project\Coordinator;..\RTT_P2P\Project\DistributionComponents\iniparser;.\Board\Inc;..\FTU\bsp\stm32f429-apollo\applications\common_data;..\LibIEC\libIEC61850\App
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\SCRIPT\rt1052_flexspi_scf.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c
    ../FTU/components/net/lwip-1.3.2/apps/: tftp.c
  group Drivers
    drivers/: board.c drv_uart.c drv_cache.c drv_sdram.c drv_pin.c drv_rtc.c drv_spi_bus.c drv_i2c.c drv_lcd.c drv_sdio.c drv_pcf8574.c drv_eth_ATK.c fsl_phy_ATK.c
  group Libraries
    Libraries/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    Libraries/: system_MIMXRT1052.c
    Libraries/arm/: startup_MIMXRT1052.s
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler.c signal.c thread.c timer.c
    ./: rtconfig.h
  group CORTEX-M7
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group libiec/common
    ../LibIEC/libIEC61850/src/common/: array_list.c buffer_chain.c byte_buffer.c conversions.c lib_memory.c linked_list.c map.c mem_alloc_linked_list.c simple_allocator.c string_map.c string_utilities.c errno.c
    ../LibIEC/libIEC61850/src/mms/iso_mms/asn1c/: INTEGER.h
  group libiec/goose
    ../LibIEC/libIEC61850/src/goose/: goose_publisher.c goose_receiver.c goose_subscriber.c
  group libiec/iec61850
    ../LibIEC/libIEC61850/src/iec61850/client/: client_control.c client_goose_control.c client_report.c client_report_control.c client_sv_control.c ied_connection.c
    ../LibIEC/libIEC61850/src/iec61850/common/: iec61850_common.c
    ../LibIEC/libIEC61850/src/iec61850/server/mms_mapping/: control.c logging.c mms_goose.c mms_mapping.c mms_sv.c reporting.c
    ../LibIEC/libIEC61850/src/iec61850/server/impl/: client_connection.c ied_server.c ied_server_config.c
  group libiec/iec61850/model
    ../LibIEC/libIEC61850/src/iec61850/server/model/: cdc.c config_file_parser.c dynamic_model.c model.c
  group libiec/logging
    ../LibIEC/libIEC61850/src/logging/drivers/: log_storage.c
  group libiec/mms
    ../LibIEC/libIEC61850/src/mms/asn1/: asn1_ber_primitive_value.c ber_decode.c ber_encoder.c ber_integer.c
    ../LibIEC/libIEC61850/src/mms/iso_acse/: acse.c
    ../LibIEC/libIEC61850/src/mms/iso_client/: iso_client_connection.c
    ../LibIEC/libIEC61850/src/mms/iso_common/: iso_connection_parameters.c
    ../LibIEC/libIEC61850/src/mms/iso_cotp/: cotp.c
    ../LibIEC/libIEC61850/src/mms/iso_mms/asn1c/: AccessResult.c Address.c AlternateAccess.c AlternateAccessSelection.c asn_codecs_prim.c asn_SEQUENCE_OF.c asn_SET_OF.c ber_decoder.c ber_tlv_length.c ber_tlv_tag.c BIT_STRING.c BOOLEAN.c ConcludeRequestPDU.c ConcludeResponsePDU.c ConfirmedErrorPDU.c ConfirmedRequestPdu.c ConfirmedResponsePdu.c ConfirmedServiceRequest.c ConfirmedServiceResponse.c constr_CHOICE.c constr_SEQUENCE.c constr_SEQUENCE_OF.c constr_SET_OF.c constr_TYPE.c constraints.c Data.c DataAccessError.c DataSequence.c DefineNamedVariableListRequest.c DefineNamedVariableListResponse.c DeleteNamedVariableListRequest.c DeleteNamedVariableListResponse.c der_encoder.c FloatingPoint.c GeneralizedTime.c GetNamedVariableListAttributesRequest.c GetNamedVariableListAttributesResponse.c GetNameListRequest.c GetNameListResponse.c GetVariableAccessAttributesRequest.c GetVariableAccessAttributesResponse.c Identifier.c IndexRangeSeq.c InformationReport.c InitiateErrorPdu.c InitiateRequestPdu.c InitiateResponsePdu.c InitRequestDetail.c InitResponseDetail.c INTEGER.c Integer8.c Integer16.c Integer32.c ListOfVariableSeq.c MmsPdu.c MMSString.c NativeEnumerated.c NativeInteger.c NULL.c ObjectClass.c ObjectName.c OCTET_STRING.c ParameterSupportOptions.c per_decoder.c per_encoder.c per_support.c ReadRequest.c ReadResponse.c RejectPDU.c ScatteredAccessDescription.c ServiceError.c ServiceSupportOptions.c StructComponent.c TimeOfDay.c TypeSpecification.c UnconfirmedPDU.c UnconfirmedService.c Unsigned8.c Unsigned16.c Unsigned32.c UtcTime.c UTF8String.c VariableAccessSpecification.c VariableSpecification.c VisibleString.c WriteRequest.c WriteResponse.c xer_decoder.c xer_encoder.c xer_support.c
    ../LibIEC/libIEC61850/src/mms/iso_mms/client/: mms_client_common.c mms_client_connection.c mms_client_files.c mms_client_get_namelist.c mms_client_get_var_access.c mms_client_identify.c mms_client_initiate.c mms_client_journals.c mms_client_named_variable_list.c mms_client_read.c mms_client_status.c mms_client_write.c
    ../LibIEC/libIEC61850/src/mms/iso_mms/common/: mms_common_msg.c mms_type_spec.c mms_value.c
    ../LibIEC/libIEC61850/src/mms/iso_mms/server/: mms_access_result.c mms_association_service.c mms_device.c mms_domain.c mms_file_service.c mms_get_namelist_service.c mms_get_var_access_service.c mms_identify_service.c mms_information_report.c mms_journal.c mms_journal_service.c mms_named_variable_list.c mms_named_variable_list_service.c mms_read_service.c mms_server.c mms_server_common.c mms_server_connection.c mms_status_service.c mms_value_cache.c mms_write_service.c
    ../LibIEC/libIEC61850/src/mms/iso_presentation/: iso_presentation.c
    ../LibIEC/libIEC61850/src/mms/iso_server/: iso_connection.c iso_server.c
    ../LibIEC/libIEC61850/src/mms/iso_session/: iso_session.c
  group libiec/sampled_values
    ../LibIEC/libIEC61850/src/sampled_values/: sv_publisher.c sv_subscriber.c
  group libiec/hal
    ../RTT_P2P/Project/libiec_hal/filesystem/dtu_rtt/: file_provider_rtt.c
    ../RTT_P2P/Project/libiec_hal/thread/rt_thread/: thread_rtt.c
    ../RTT_P2P/Project/libiec_hal/time/dtu_core/: time_libiec.c
    ../RTT_P2P/Project/libiec_hal/socket/imx_rtt/: socket_rtt.c
    ../RTT_P2P/Project/libiec_hal/ethernet/imx_rtt/: ethernet_rtt.c
  group libiec/GooseAPP
    ../LibIEC/libIEC61850/App/: goose_publisher_example.c goose_misc.c
    ../LibIEC/libIEC61850/GooseTransmission/: goose_publisher_beat.c
  group libiec/ServerAPP
    ../LibIEC/libIEC61850/App/: iec61850_app.c ied_data_ref.c ied_data_ref_init.c server_datamapping.c server_model.c server_model.h
  group libiec/Iniparser
    ../RTT_P2P/Project/DistributionComponents/iniparser/: dictionary.c dictionary.h gooseparser.c gooseparser.h iniparser.c iniparser.h ParserThread.c ParserThread.h
  group Distribution
    ../RTT_P2P/Project/Distribution/Src/: distribution_connect.c distribution_helper.c distribution_test_case.c distribution_transfer.c distribution_online.c distribution_monitor.c fault_deal.c fault_insulate.c fault_removal.c fault_treatment.c parse_implement.c power_area.c topology.c distribution_interface.c
    ../RTT_P2P/Project/Distribution/Inc/: distribution_config.h
  group Distribution/Mutal
    ../RTT_P2P/Project/Distribution/Src/: RouterDatagram.c Router.c extern_mutual.c
  group Distribution/Components
    ../RTT_P2P/Project/Components/Src/: Buffer.c helper.c list.c RingQueue.c
    ../RTT_P2P/Project/DistributionComponents/: log.c log.pb.c station.pb.c station.c
  group Distribution/Coordinator
    ../RTT_P2P/Project/Coordinator/: Coordinator.c
    ../RTT_P2P/Project/Distribution/Src/: status_update.c
  group Distribution/Simulatin
    ../RTT_P2P/Project/Distribution/Src/: station_manager.c logical_simulation.c
  group Protocol/nanopb
    ../RTT_P2P/Project/Protocol/nanopb/: pb_common.c pb_decode.c pb_encode.c
  group Protocol/RTUself
    ../RTT_P2P/Project/Protocol/Src/: CRC16.c Datagram.c RtuFrame.c
  group Distribution/Board
    ./Board/Src/: database.c ethernet_hook.c miscellaneous.c w5500_server.c
  group Distribution/APP
    ../RTT_P2P/Project/APP/Src/: distribution_app.c logical_app.c logical_simulation_app.c mutal_app.c
    ./applications/: communicaton.c
software components: CMSIS:CORE 5.0.2
